# Keil uVision project blink_nrf.uvprojx, settings and files
target test_inactividad (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: blink_nrf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: modo_test_inactividad_nrf
  c include: ../src_nrf
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  group Source Comun
    ../../src/: main.c board.h drv_tiempo.h drv_tiempo.c drv_leds.h drv_leds.c drv_botones.h drv_botones.c drv_monitor.h drv_monitor.c drv_consumo.h drv_consumo.c hal_gpio.h hal_tiempo.h hal_ext_int.h hal_consumo.h hal_WDG.h rt_evento_t.h rt_fifo.h rt_fifo.c rt_estadisticas.h rt_estadisticas.c rt_GE.h rt_GE.c svc_GE.h svc_alarmas.h svc_alarmas.c simon.h simon.c rt_sc.h rt_sc.c test_rt_fifo.h test_rt_fifo.c
  group Dependientes
    ../src_nrf/: hal_gpio_nrf.c hal_gpio_nrf.h hal_tiempo_nrf.c board_nrf52840dk.h board_nrf52840_dongle.h hal_consumo_nrf.c hal_ext_int_nrf.c hal_WDG_nrf.c
target test_WDG (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: blink_nrf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: modo_test_WDG_nrf
  c include: ../src_nrf
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
target simon (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: blink_nrf +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: modo_simon_nrf
  c include: ../src_nrf
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
target depuracion (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: blink_nrf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: modo_depuracion_nrf
  c include: ../src_nrf
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
software components: CMSIS:CORE 5.3.0, Device:Startup 8.44.1
